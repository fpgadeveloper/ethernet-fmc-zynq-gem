SRC_URI += "file://user.cfg \
            file://macb-gmii2rgmii.patch \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

